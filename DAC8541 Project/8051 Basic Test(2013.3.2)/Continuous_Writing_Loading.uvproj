# Keil uVision project Continuous_Writing_Loading.uvproj, settings and files
target MPC82G516 (MCS-51)
  device: MPC82G516 Megawin
  cpu: IRAM(0-0xFF) IROM(0-0xFFFF) XRAM (0-0x3FF) CLOCK(24000000)
  output: Continuous_Writing_Loading +hex
  c flags: Optimize=8 SizeSpeed=1
  group Main
    ./: Continuous_Writing_Loading.c
  group Source
    ./: DAC8541_Ctrl.c delaytime.c ADC_Ctrl.c
